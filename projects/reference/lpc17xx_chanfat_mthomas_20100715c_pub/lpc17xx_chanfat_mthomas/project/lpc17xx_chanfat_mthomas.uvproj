# Keil uVision project lpc17xx_chanfat_mthomas.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lpc17xx_chanfat_mthomas +hex
  AfterMake: proj_objdump.cmd "$L@L.elf" "$L@L.lss"
  group Source Group 1
    ./: startup_LPC17xx.S main.c comm.c ff_test_term.c monitor.c rtc_cal.c
    ./Libraries/NXP/Drivers/source/: lpc17xx_uart.c lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_ssp.c lpc17xx_rtc.c lpc17xx_gpdma.c
    ./Libraries/NXP/Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    ./Libraries/NXP/Core/CM3/CoreSupport/: core_cm3.c
    ./Libraries/fat_sd/: spi_sd_lpc17xx.c diskio.c fattime.c ff.c
    ./Libraries/fat_sd/option/: ccsbcs.c
    ./Libraries/USBHostLite/: usbhost_ms.c usbhost_lpc17xx.c
  group other
    ./: readme.txt
